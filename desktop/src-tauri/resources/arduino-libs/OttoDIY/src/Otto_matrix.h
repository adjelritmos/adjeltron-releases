#pragma once
// Otto_matrix.h — matriz de LEDs 8×8 com MAX7219 (a boca do Otto): ligação por software em
// DIN, CS (LOAD) e CLK. writeFull() desenha uma boca de 30 bits; rotação 1–4 (0°, 90°, 180°, 270°).
#include <Arduino.h>
#include "Otto_gestures.h"
#define max7219_reg_noop 0x00
#define max7219_reg_digit0 0x01
#define max7219_reg_digit1 0x02
#define max7219_reg_digit2 0x03
#define max7219_reg_digit3 0x04
#define max7219_reg_digit4 0x05
#define max7219_reg_digit5 0x06
#define max7219_reg_digit6 0x07
#define max7219_reg_digit7 0x08
#define max7219_reg_decodeMode 0x09
#define max7219_reg_intensity 0x0a
#define max7219_reg_scanLimit 0x0b
#define max7219_reg_shutdown 0x0c
#define max7219_reg_displayTest 0x0f
// tipo de letra 5×7 (ASCII 32–126; 5 colunas por carácter, bit 0 = linha de cima)
static const byte OttoFont5x7[475] PROGMEM = {
  0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x5f, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00,
  0x14, 0x7f, 0x14, 0x7f, 0x14,
  0x24, 0x2a, 0x7f, 0x2a, 0x12,
  0x23, 0x13, 0x08, 0x64, 0x62,
  0x36, 0x49, 0x55, 0x22, 0x50,
  0x00, 0x05, 0x03, 0x00, 0x00,
  0x00, 0x1c, 0x22, 0x41, 0x00,
  0x00, 0x41, 0x22, 0x1c, 0x00,
  0x14, 0x08, 0x3e, 0x08, 0x14,
  0x08, 0x08, 0x3e, 0x08, 0x08,
  0x00, 0x50, 0x30, 0x00, 0x00,
  0x08, 0x08, 0x08, 0x08, 0x08,
  0x00, 0x60, 0x60, 0x00, 0x00,
  0x20, 0x10, 0x08, 0x04, 0x02,
  0x3e, 0x51, 0x49, 0x45, 0x3e,
  0x00, 0x42, 0x7f, 0x40, 0x00,
  0x42, 0x61, 0x51, 0x49, 0x46,
  0x21, 0x41, 0x45, 0x4b, 0x31,
  0x18, 0x14, 0x12, 0x7f, 0x10,
  0x27, 0x45, 0x45, 0x45, 0x39,
  0x3c, 0x4a, 0x49, 0x49, 0x30,
  0x01, 0x71, 0x09, 0x05, 0x03,
  0x36, 0x49, 0x49, 0x49, 0x36,
  0x06, 0x49, 0x49, 0x29, 0x1e,
  0x00, 0x36, 0x36, 0x00, 0x00,
  0x00, 0x56, 0x36, 0x00, 0x00,
  0x08, 0x14, 0x22, 0x41, 0x00,
  0x14, 0x14, 0x14, 0x14, 0x14,
  0x00, 0x41, 0x22, 0x14, 0x08,
  0x02, 0x01, 0x51, 0x09, 0x06,
  0x32, 0x49, 0x79, 0x41, 0x3e,
  0x7e, 0x11, 0x11, 0x11, 0x7e,
  0x7f, 0x49, 0x49, 0x49, 0x36,
  0x3e, 0x41, 0x41, 0x41, 0x22,
  0x7f, 0x41, 0x41, 0x22, 0x1c,
  0x7f, 0x49, 0x49, 0x49, 0x41,
  0x7f, 0x09, 0x09, 0x09, 0x01,
  0x3e, 0x41, 0x49, 0x49, 0x7a,
  0x7f, 0x08, 0x08, 0x08, 0x7f,
  0x00, 0x41, 0x7f, 0x41, 0x00,
  0x20, 0x40, 0x41, 0x3f, 0x01,
  0x7f, 0x08, 0x14, 0x22, 0x41,
  0x7f, 0x40, 0x40, 0x40, 0x40,
  0x7f, 0x02, 0x0c, 0x02, 0x7f,
  0x7f, 0x04, 0x08, 0x10, 0x7f,
  0x3e, 0x41, 0x41, 0x41, 0x3e,
  0x7f, 0x09, 0x09, 0x09, 0x06,
  0x3e, 0x41, 0x51, 0x21, 0x5e,
  0x7f, 0x09, 0x19, 0x29, 0x46,
  0x46, 0x49, 0x49, 0x49, 0x31,
  0x01, 0x01, 0x7f, 0x01, 0x01,
  0x3f, 0x40, 0x40, 0x40, 0x3f,
  0x1f, 0x20, 0x40, 0x20, 0x1f,
  0x3f, 0x40, 0x38, 0x40, 0x3f,
  0x63, 0x14, 0x08, 0x14, 0x63,
  0x07, 0x08, 0x70, 0x08, 0x07,
  0x61, 0x51, 0x49, 0x45, 0x43,
  0x00, 0x7f, 0x41, 0x41, 0x00,
  0x02, 0x04, 0x08, 0x10, 0x20,
  0x00, 0x41, 0x41, 0x7f, 0x00,
  0x04, 0x02, 0x01, 0x02, 0x04,
  0x40, 0x40, 0x40, 0x40, 0x40,
  0x00, 0x01, 0x02, 0x04, 0x00,
  0x20, 0x54, 0x54, 0x54, 0x78,
  0x7f, 0x48, 0x44, 0x44, 0x38,
  0x38, 0x44, 0x44, 0x44, 0x20,
  0x38, 0x44, 0x44, 0x48, 0x7f,
  0x38, 0x54, 0x54, 0x54, 0x18,
  0x08, 0x7e, 0x09, 0x01, 0x02,
  0x0c, 0x52, 0x52, 0x52, 0x3e,
  0x7f, 0x08, 0x04, 0x04, 0x78,
  0x00, 0x44, 0x7d, 0x40, 0x00,
  0x20, 0x40, 0x44, 0x3d, 0x00,
  0x7f, 0x10, 0x28, 0x44, 0x00,
  0x00, 0x41, 0x7f, 0x40, 0x00,
  0x7c, 0x04, 0x18, 0x04, 0x78,
  0x7c, 0x08, 0x04, 0x04, 0x78,
  0x38, 0x44, 0x44, 0x44, 0x38,
  0x7c, 0x14, 0x14, 0x14, 0x08,
  0x08, 0x14, 0x14, 0x18, 0x7c,
  0x7c, 0x08, 0x04, 0x04, 0x08,
  0x48, 0x54, 0x54, 0x54, 0x20,
  0x04, 0x3f, 0x44, 0x40, 0x20,
  0x3c, 0x40, 0x40, 0x20, 0x7c,
  0x1c, 0x20, 0x40, 0x20, 0x1c,
  0x3c, 0x40, 0x30, 0x40, 0x3c,
  0x44, 0x28, 0x10, 0x28, 0x44,
  0x0c, 0x50, 0x50, 0x50, 0x3c,
  0x44, 0x64, 0x54, 0x4c, 0x44,
  0x00, 0x08, 0x36, 0x41, 0x00,
  0x00, 0x00, 0x7f, 0x00, 0x00,
  0x00, 0x41, 0x36, 0x08, 0x00,
  0x08, 0x04, 0x08, 0x10, 0x08,
};
static byte OttoFontColumn(char c, int k) {
  if (c < 32 || c > 126) return 0x7f;
  return pgm_read_byte(&OttoFont5x7[(c - 32) * 5 + k]);
}

class Otto_Matrix {
 public:
  Otto_Matrix() {
    _data = 255;
    _load = 255;
    _clock = 255;
    _num = 1;
    _rotation = 1;
    for (int i = 0; i < 8; i++) _buffer[i] = 0;
  }
  void init(byte data, byte load, byte clock, byte num, int rotation) {
    _data = data;
    _load = load;
    _clock = clock;
    _num = num;
    _rotation = rotation;
    _begin();
  }
  bool ready() { return _data != 255; }
  void clearMatrix() {
    for (int i = 0; i < 8; i++) _buffer[i] = 0;
    _flush();
  }
  void setCommand(byte command, byte value) {
    if (!ready()) return;
    _pulse(command, value, -1);
  }
  void setIntensity(byte intensity) { setCommand(max7219_reg_intensity, intensity & 0x0f); }
  // linha "col" (0–7) da imagem (bits 7…0 = da esquerda para a direita)
  void setColumn(byte col, byte value) {
    if (col > 7) return;
    _buffer[col] = value;
    _flush();
  }
  void setColumnAll(byte col, byte value) { setColumn(col, value); }
  void setDot(byte col, byte row, byte value) {
    if (col > 7 || row > 7) return;
    if (value) _buffer[row] |= (0x80 >> col);
    else _buffer[row] &= ~(0x80 >> col);
    _flush();
  }
  // boca de 6 × 5 (30 bits) ao centro da matriz
  void writeFull(unsigned long value) {
    for (int i = 0; i < 8; i++) _buffer[i] = 0;
    for (int r = 0; r < 5; r++)
      for (int c = 0; c < 6; c++)
        if ((value >> (29 - (r * 6 + c))) & 1UL) _buffer[r + 2] |= (0x80 >> (c + 1));
    _flush();
  }
  // texto a passar da direita para a esquerda (só a parte visível de 8 colunas)
  void sendChar(const byte data, byte pos, byte number, byte scrollspeed) {
    int x = 8 - (int)scrollspeed;
    if (number == 0) return;
    for (int i = 0; i < 8; i++) _buffer[i] = 0;
    for (int k = 0; k < 5; k++) {
      int col = pos * 6 + k + x;
      if (col < 0 || col > 7) continue;
      byte bits = OttoFontColumn((char)data, k);
      for (int r = 0; r < 7; r++)
        if (bits & (1 << r)) _buffer[r] |= (0x80 >> col);
    }
    _flush();
  }
  void writeText(const char *s, byte scrollspeed) {
    int n = strlen(s);
    int width = n * 6;
    for (int off = -8; off <= width; off++) {
      for (int i = 0; i < 8; i++) _buffer[i] = 0;
      for (int col = 0; col < 8; col++) {
        int gx = off + col;
        if (gx < 0 || gx >= width) continue;
        int ci = gx / 6;
        int k = gx % 6;
        if (k == 5) continue;
        byte bits = OttoFontColumn(s[ci], k);
        for (int r = 0; r < 7; r++)
          if (bits & (1 << r)) _buffer[r] |= (0x80 >> col);
      }
      _flush();
      delay(scrollspeed);
    }
    clearMatrix();
  }

 private:
  void _pulse(byte reg, byte value, int module) {
    digitalWrite(_load, LOW);
    for (int m = _num - 1; m >= 0; m--) {
      if (module < 0 || m == module) {
        shiftOut(_data, _clock, MSBFIRST, reg);
        shiftOut(_data, _clock, MSBFIRST, value);
      } else {
        shiftOut(_data, _clock, MSBFIRST, 0);
        shiftOut(_data, _clock, MSBFIRST, 0);
      }
    }
    digitalWrite(_load, HIGH);
  }
  void _begin() {
    if (_num < 1) _num = 1;
    if (_num > 8) _num = 8;
    pinMode(_data, OUTPUT);
    pinMode(_clock, OUTPUT);
    pinMode(_load, OUTPUT);
    digitalWrite(_clock, LOW);
    digitalWrite(_load, HIGH);
    setCommand(max7219_reg_scanLimit, 0x07);
    setCommand(max7219_reg_decodeMode, 0x00);
    setCommand(max7219_reg_shutdown, 0x01);
    setCommand(max7219_reg_displayTest, 0x00);
    clearMatrix();
    setIntensity(0x0f);
  }
  // aplica a rotação e envia as 8 linhas
  void _flush() {
    if (!ready()) return;
    for (int r = 0; r < 8; r++) {
      byte out = 0;
      for (int c = 0; c < 8; c++) {
        int sr = r;
        int sc = c;
        if (_rotation == 2) {
          sr = 7 - c;
          sc = r;
        } else if (_rotation == 3) {
          sr = 7 - r;
          sc = 7 - c;
        } else if (_rotation == 4) {
          sr = c;
          sc = 7 - r;
        }
        if (_buffer[sr] & (0x80 >> sc)) out |= (0x80 >> c);
      }
      _pulse(r + 1, out, -1);
    }
  }
  byte _data;
  byte _load;
  byte _clock;
  byte _num;
  int _rotation;
  byte _buffer[8];
};
